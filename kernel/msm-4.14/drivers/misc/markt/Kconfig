## kernel/msm-4.14/drivers/misc/markt/Kconfig
```kconfig
menu "MARKT factory info support"
config MARKT_FACTORY_INFO
	bool  "Select use markt factory info"
	default n
endmenu
```
